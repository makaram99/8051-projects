# Keil uVision project washer.uvproj, settings and files
target washer (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: washer +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group src
    ./: STARTUP.A51
    ./src/: cuteOS.c main.c washer.c washer_cfg.c
  group include
    ./include/: BIT_MATH.h cuteOS.h main.h port.h STD_TYPES.h washer.h washer_cfg.h
