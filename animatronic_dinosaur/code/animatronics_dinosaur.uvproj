# Keil uVision project animatronics_dinosaur.uvproj, settings and files
target 8052 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: animatronics_dinosaur +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group src
    ./: STARTUP.A51
    ./src/: cuteOS.c dinosaur.c dinosaur_cfg.c main.c
  group include
    ./include/: BIT_MATH.h cuteOS.h dinosaur.h dinosaur_cfg.h main.h port.h STD_TYPES.h
